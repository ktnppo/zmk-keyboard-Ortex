## boards/shields/ortex/Kconfig.shield
```kconfig
config SHIELD_ORTEX_L
   def_bool $(shields_list_contains,ortex_l)

config SHIELD_ORTEX_R
   def_bool $(shields_list_contains,ortex_r)
```
